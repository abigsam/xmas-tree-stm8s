<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\xmas_tree.ewp</path>
    </project>
    <batchBuild />
</workspace>
